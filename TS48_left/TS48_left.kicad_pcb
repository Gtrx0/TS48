# Repository Gtrx0/TS48

## KiCad design TS48_left/TS48_left.kicad_pcb

Parts:
C1: 0.1uf; C_0805_HandSoldering
C2, C3, C5, C9, C10, C11, C12, C13, C14, C15: 0.1uF; C_0805_HandSoldering
C4, C7: 4.7uF; C_0805_HandSoldering
C6: 1uF; C_0805_HandSoldering
F1: 500mA Hold; Fuse_SMD1206_HandSoldering
LED1, LED2, LED3, LED4, LED5, LED6, LED7: WS2812B
NPNR1: 1.5k; R_0805_HandSoldering
Q1: Q_NPN_BCE; SOT-23_Handsoldering
R1, R2: 10k; R_0805_HandSoldering
R3, R4: 4.7k; R_0805_HandSoldering
RGBR1: 470; R_0805_HandSoldering
SPI1: 2x3 SPI; Pin_Header_Straight_2x03_Pitch1.27mm
SW1: SW_PUSH; CandK_6x6mm_Tactile
TRRS1: TRRS1; TRRS-PJ-320A
U1: ATmega32U4; QFP44
U2: PRTR5V0U2X; SOT143B
UR1, UR2: 22; R_0805_HandSoldering
UR3, UR4: 5.1k; R_0805_HandSoldering
UR5: 1M; R_0805_HandSoldering
USB1: HRO-TYPE-C-31-M-12; HRO-TYPE-C-31-M-12-HandSoldering
XC1, XC2: 22pF; C_0805_HandSoldering
Y1: Crystal_GND2; Crystal_SMD_3225-4pin_3.2x2.5mm

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, F1.2, LED1.1 (VCC), LED2.1 (VCC), LED3.1 (VCC), LED4.1 (VCC), LED5.1 (VCC), LED6.1 (VCC), LED7.1 (VCC), R1.1, R3.1, R4.2, SPI1.2, TRRS1.3, U1.2, U1.7, U1.14, U1.24, U1.34, U1.44; also elsewhere on the board
COL0: U1.1; also elsewhere on the board
COL1: U1.31; also elsewhere on the board
COL2: U1.28; also elsewhere on the board
COL3: U1.27; also elsewhere on the board
COL4: U1.26; also elsewhere on the board
COL5: U1.25; also elsewhere on the board
D+: U1.4, UR2.1
D-: U1.3, UR1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, LED1.3 (GND), LED2.3 (GND), LED3.3 (GND), LED4.3 (GND), LED5.3 (GND), LED6.3 (GND), LED7.3 (GND), Q1.3 (E), R2.2, SPI1.6, SW1.1, TRRS1.4, U1.5, U1.15, U1.23, U1.35, U1.43, U2.1 (GND), UR3.1, UR4.2, UR5.1, USB1.1 (GND), USB1.12 (GND), XC1.2, XC2.2, Y1.2
LEDGND: Q1.2 (C); also elsewhere on the board
LEDPWM: NPNR1.1, U1.29
MISO: SPI1.1, U1.11
MOSI: SPI1.4, U1.10
unnamed: C6.2, U1.6
unnamed: C7.2, UR5.2, USB1.13 (SHIELD)
unnamed: LED1.2 (DOUT), LED2.4 (DIN)
unnamed: LED1.4 (DIN), RGBR1.2
unnamed: LED2.2 (DOUT), LED3.4 (DIN)
unnamed: LED3.2 (DOUT), LED4.4 (DIN)
unnamed: LED4.2 (DOUT), LED5.4 (DIN)
unnamed: LED5.2 (DOUT), LED6.4 (DIN)
unnamed: LED6.2 (DOUT), LED7.4 (DIN)
unnamed: NPNR1.2, Q1.1 (B)
unnamed: R2.1, U1.33
unnamed: U1.16, XC2.1, Y1.3
unnamed: U1.17, XC1.1, Y1.1
unnamed: U2.2 (IO1), UR2.2, USB1.6 (DP1), USB1.8 (DP2)
unnamed: U2.3 (IO2), UR1.1, USB1.5 (DN2), USB1.7 (DN1)
unnamed: UR3.2, USB1.10 (CC2)
unnamed: UR4.1, USB1.4 (CC1)
RGBIN: RGBR1.1, U1.30
ROW0: U1.41; also elsewhere on the board
ROW1: U1.40; also elsewhere on the board
ROW2: U1.39; also elsewhere on the board
ROW3: U1.38; also elsewhere on the board
RST: R1.2, SPI1.5, SW1.2, U1.13
SCK: SPI1.3, U1.9
SCL-: R3.2, TRRS1.2, U1.18
SDA+: R4.1, TRRS1.1, U1.19
VCC: F1.1, U2.4 (VCC), USB1.2 (VBUS), USB1.11 (VBUS)

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24: D_ALT; D_SOD-123
MX1, MX2, MX3, MX4, MX5, MX6, MX8, MX9, MX10, MX11, MX12, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX24, MX27: MX-1U
MX7, MX23, MX25, MX26, MX28: MX-1.25U
MX13, MX30: MX-1.5U
MX29: MX-2.25U
R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28: R_Small; R_0805_HandSoldering

Connections:
+5V: MX1.3 (LED), MX2.3 (LED), MX3.3 (LED), MX4.3 (LED), MX5.3 (LED), MX6.3 (LED), MX7.3 (LED), MX8.3 (LED), MX9.3 (LED), MX10.3 (LED), MX11.3 (LED), MX12.3 (LED), MX13.3 (LED), MX14.3 (LED), MX15.3 (LED), MX16.3 (LED), MX17.3 (LED), MX18.3 (LED), MX19.3 (LED), MX20.3 (LED), MX21.3 (LED), MX22.3 (LED), MX23.3 (LED), MX24.4 (LEDGND), MX25.4 (LEDGND), MX26.3 (LED), MX27.3 (LED), MX28.3 (LED), MX29.3 (LED), MX30.3 (LED); also elsewhere on the board
COL0: MX1.1 (COL), MX7.1 (COL), MX13.1 (COL), MX19.1 (COL), MX25.1 (COL); also elsewhere on the board
COL1: MX2.1 (COL), MX8.1 (COL), MX14.1 (COL), MX20.1 (COL), MX26.2 (ROW); also elsewhere on the board
COL2: MX3.1 (COL), MX9.1 (COL), MX15.1 (COL), MX21.1 (COL); also elsewhere on the board
COL3: MX4.1 (COL), MX10.1 (COL), MX16.1 (COL), MX22.1 (COL), MX28.2 (ROW); also elsewhere on the board
COL4: MX5.1 (COL), MX11.1 (COL), MX17.1 (COL), MX23.1 (COL), MX27.2 (ROW); also elsewhere on the board
COL5: MX6.1 (COL), MX12.1 (COL), MX18.1 (COL), MX24.1 (COL), MX29.1 (COL), MX30.2 (ROW); also elsewhere on the board
LEDGND: R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2; also elsewhere on the board
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: D5.2 (A), MX5.2 (ROW)
unnamed: D6.2 (A), MX6.2 (ROW)
unnamed: D7.2 (A), MX7.2 (ROW)
unnamed: D8.2 (A), MX8.2 (ROW)
unnamed: D9.2 (A), MX9.2 (ROW)
unnamed: D10.2 (A), MX10.2 (ROW)
unnamed: D11.2 (A), MX11.2 (ROW)
unnamed: D12.2 (A), MX12.2 (ROW)
unnamed: D13.2 (A), MX13.2 (ROW)
unnamed: D14.2 (A), MX14.2 (ROW)
unnamed: D15.2 (A), MX15.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), MX18.2 (ROW)
unnamed: D19.2 (A), MX19.2 (ROW), MX25.2 (ROW)
unnamed: D20.2 (A), MX20.2 (ROW), MX26.1 (COL)
unnamed: D21.2 (A), MX21.2 (ROW)
unnamed: D22.2 (A), MX22.2 (ROW), MX28.1 (COL)
unnamed: D23.2 (A), MX23.2 (ROW), MX27.1 (COL)
unnamed: D24.2 (A), MX24.2 (ROW), MX29.2 (ROW), MX30.1 (COL)
unnamed: MX1.4 (LEDGND), R28.1
unnamed: MX2.4 (LEDGND), R5.1
unnamed: MX3.4 (LEDGND), R6.1
unnamed: MX4.4 (LEDGND), R7.1
unnamed: MX5.4 (LEDGND), R8.1
unnamed: MX6.4 (LEDGND), R9.1
unnamed: MX7.4 (LEDGND), R10.1
unnamed: MX8.4 (LEDGND), R11.1
unnamed: MX9.4 (LEDGND), R12.1
unnamed: MX10.4 (LEDGND), R13.1
unnamed: MX11.4 (LEDGND), R14.1
unnamed: MX12.4 (LEDGND), R15.1
unnamed: MX13.4 (LEDGND), R16.1
unnamed: MX14.4 (LEDGND), R17.1
unnamed: MX15.4 (LEDGND), R18.1
unnamed: MX16.4 (LEDGND), R19.1
unnamed: MX17.4 (LEDGND), R20.1
unnamed: MX18.4 (LEDGND), R21.1
unnamed: MX19.4 (LEDGND), MX25.3 (LED), R22.1
unnamed: MX20.4 (LEDGND), MX26.4 (LEDGND), R23.1
unnamed: MX21.4 (LEDGND), R24.1
unnamed: MX22.4 (LEDGND), MX28.4 (LEDGND), R25.1
unnamed: MX23.4 (LEDGND), MX27.4 (LEDGND), R26.1
unnamed: MX24.3 (LED), MX29.4 (LEDGND), MX30.4 (LEDGND), R27.1
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K); also elsewhere on the board
ROW1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K); also elsewhere on the board
ROW2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K); also elsewhere on the board
ROW3: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K); also elsewhere on the board

Board: 2 copper layers, 124.0 x 77.9 mm, 121 parts (91 on the bottom side), 89 nets.

## Commit log

2018-09-04 TS48
2018-09-04 Changes to be committed:
2018-09-06 Layout changes
2018-09-07 Removed uneeded files
2018-09-08 Routing
2018-09-09 Routed board
2018-09-14 Optimising routing
2018-09-15 Logos
2018-09-15 Silkscreen
2018-12-05 Gerbers
2018-12-05 cLEANUP
2019-06-30 PCB design
